# Keil uVision project VectorFly.uvprojx, settings and files
target VectorFly (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VectorFly +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F401xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,ARM_MATH_CM4
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\BSP\inc;..\APP\inc;..\USB\USB_APP\interface;..\USB\USB_CORE\inc;..\USB\USB_DEVICE\Core\inc;..\USB\USB_DEVICE\Class\cdc\inc;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CONFIG\inc;..\COMMON\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_exti.c
  group CONFIG
    ../CONFIG/inc/: stm32f4xx_conf.h FreeRTOSConfig.h config.h
  group COMMON
    ../COMMON/src/: filter.c pid.c sort.c i2cdrv.c
  group BSP
    ../BSP/src/: bsp.c bsp_led.c bsp_rcc.c bsp_timer.c bsp_uart.c bsp_motor.c bsp_mpu.c bsp_magnet.c
  group APP
    ../APP/src/: app_ano.c app_usblink.c app_uartlink.c app_led.c app_sensor.c app_attitude.c
  group USB_CORE
    ../USB/USB_CORE/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USB/USB_DEVICE/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/USB_DEVICE/Class/cdc/src/: usbd_cdc_core.c
  group USB_APP
    ../USB/USB_APP/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c event_groups.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
